#include "font.h"




/************** alphabet **************/
const uint64_t a [] = {0x0C, 0x1E, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x00};
const map_t A [] = {{8, 8, a}};

const uint64_t b [] = {0x3F, 0x66, 0x66, 0x3E, 0x66, 0x66, 0x3F, 0x00};
const map_t B [] = {{8, 8, b}};

const uint64_t c [] = {0x3C, 0x66, 0x03, 0x03, 0x03, 0x66, 0x3C, 0x00};
const map_t C [] = {{8, 8, c}};

const uint64_t d [] = {0x1F, 0x36, 0x66, 0x66, 0x66, 0x36, 0x1F, 0x00};
const map_t D [] = {{8, 8, d}};

const uint64_t e [] = {0x7F, 0x46, 0x16, 0x1E, 0x16, 0x46, 0x7F, 0x00};
const map_t E [] = {{8, 8, e}};

const uint64_t f [] = {0x7F, 0x46, 0x16, 0x1E, 0x16, 0x06, 0x0F, 0x00};
const map_t F [] = {{8, 8, f}};

const uint64_t g [] = {0x3C, 0x66, 0x03, 0x03, 0x73, 0x66, 0x7C, 0x00};
const map_t G [] = {{8, 8, g}};

const uint64_t h [] = {0x33, 0x33, 0x33, 0x3F, 0x33, 0x33, 0x33, 0x00};
const map_t H [] = {{8, 8, h}};

const uint64_t i [] = {0x1E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00};
const map_t I [] = {{8, 8, i}};

const uint64_t j [] = {0x78, 0x30, 0x30, 0x30, 0x33, 0x33, 0x1E, 0x00};
const map_t J [] = {{8, 8, j}};

const uint64_t k [] = {0x67, 0x66, 0x36, 0x1E, 0x36, 0x66, 0x67, 0x00};
const map_t K [] = {{8, 8, k}};

const uint64_t l [] = {0x0F, 0x06, 0x06, 0x06, 0x46, 0x66, 0x7F, 0x00};
const map_t L [] = {{8, 8, l}};

const uint64_t m [] = {0x63, 0x77, 0x7F, 0x7F, 0x6B, 0x63, 0x63, 0x00};
const map_t M [] = {{8, 8, m}};

const uint64_t n [] = {0x63, 0x67, 0x6F, 0x7B, 0x73, 0x63, 0x63, 0x00};
const map_t N [] = {{8, 8, n}};

const uint64_t o [] = {0x1C, 0x36, 0x63, 0x63, 0x63, 0x36, 0x1C, 0x00};
const map_t O [] = {{8, 8, o}};

const uint64_t p [] = {0x3F, 0x66, 0x66, 0x3E, 0x06, 0x06, 0x0F, 0x00};
const map_t P [] = {{8, 8, p}};

const uint64_t q [] = {0x1E, 0x33, 0x33, 0x33, 0x3B, 0x1E, 0x38, 0x00};
const map_t Q [] = {{8, 8, q}};

const uint64_t r [] = {0x3F, 0x66, 0x66, 0x3E, 0x36, 0x66, 0x67, 0x00};
const map_t R [] = {{8, 8, r}};

const uint64_t s [] = {0x1E, 0x33, 0x07, 0x0E, 0x38, 0x33, 0x1E, 0x00};
const map_t S [] = {{8, 8, s}};

const uint64_t t [] = {0x3F, 0x2D, 0x0C, 0x0C, 0x0C, 0x0C, 0x1E, 0x00};
const map_t T [] = {{8, 8, t}};

const uint64_t u [] = {0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x00};
const map_t U [] = {{8, 8, u}};

const uint64_t v [] = {0x33, 0x33, 0x33, 0x33, 0x33, 0x1E, 0x0C, 0x00};
const map_t V [] = {{8, 8, v}};

const uint64_t w [] = {0x63, 0x63, 0x63, 0x6B, 0x7F, 0x77, 0x63, 0x00};
const map_t W [] = {{8, 8, w}};

const uint64_t x [] = {0x63, 0x63, 0x36, 0x1C, 0x1C, 0x36, 0x63, 0x00};
const map_t X [] = {{8, 8, x}};

const uint64_t y [] = {0x33, 0x33, 0x33, 0x1E, 0x0C, 0x0C, 0x1E, 0x00};
const map_t Y [] = {{8, 8, y}};

const uint64_t z [] = {0x7F, 0x63, 0x31, 0x18, 0x4C, 0x66, 0x7F, 0x00};
const map_t Z [] = {{8, 8, z}};


const map_t null_font [] = {{0, 0, NULL}};

// alphabet
const letter_t letters [] = {{A}, {B}, {C}, {D}, {E}, {F}, {G}, {H}, {I}, {J}, {K},
							 {L}, {M}, {N}, {O}, {P}, {Q}, {R}, {S}, {T}, {U}, {V},
							 {W}, {X}, {Y}, {Z}, {null_font}};

const hub75_color_t letter_colors [] = {RED, GREEN, YELLOW, BLUE, PINK, TEAL, RED,
										RED, GREEN, YELLOW, BLUE, PINK, TEAL, RED,
										RED, GREEN, YELLOW, BLUE, PINK, TEAL, RED,
										RED, GREEN, YELLOW, BLUE, PINK, TEAL, RED};


letter_t
get_letter (uint8_t idx)
{
  if (idx >= NUM_LETTERS)
  {
    return letters[NUM_LETTERS];
  }
  return letters[idx];
}

hub75_color_t
get_letter_color (uint8_t idx)
{
  if (idx >= NUM_LETTERS)
  {
    return BLACK;
  }
  return letter_colors[idx];
}

Font_t
font_init (uint8_t index, int row)
{
  // get a random number
//  int rand_idx = gen_rand_int (0, 6);

  // initialize the piece values
  Font_t new_font;
  if(row)
  {
	  new_font.x_coord = 24;
  }
  else
  {
	  new_font.x_coord = 1;
  }
  new_font.y_coord = 2;
  new_font.letter = get_letter (index);
  new_font.color = get_letter_color (index);
  return new_font;
}


